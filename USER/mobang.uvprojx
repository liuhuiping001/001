# Keil uVision project mobang.uvprojx, settings and files
target Template (ARM-ADS)
  device: STM32F407ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: mobang +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\FWLIB\inc;..\USER;..\HARDWARE\Delay;..\HARDWARE\LED;..\HARDWARE\Key;..\HARDWARE\Beep;..\HARDWARE\EXTI;..\HARDWARE\USART;..\HARDWARE\TIMER
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_exti.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_tim.c
  group HARDWARE
    ../HARDWARE/Delay/: Delay.c
    ../HARDWARE/LED/: Led.c
    ../HARDWARE/Key/: Key.c
    ../HARDWARE/Beep/: Beep.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/USART/: usart.c
    ../HARDWARE/TIMER/: timer6.c
